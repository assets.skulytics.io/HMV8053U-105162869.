Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: HMV8053U_TradeCAD.ifc
Time: 2023-03-09T20:37:21
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
HMV8053U_TradeCAD.dxf - ObjectType: SketchupComponentInstance
